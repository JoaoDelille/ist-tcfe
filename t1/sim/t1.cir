*Analise do t1

.options savecurrents

R1 1 2 1.02166163214k
R2 2 3 2.05713464724k
R3 2 4 3.10288701080k
R4 0 4 4.16870321182k
R5 4 5 3.01167607597k
R6 e 6 2.04520070018k
Ve 0 e 0.00000000000
R7 6 7 1.02576029486k

Va 1 0 5.24841080700

Rf f 5 0
Id 7 f 1.00334118042m

Gb 5 3 (2,4) 7.24529394385m
Hc 4 7 Ve 8.29202733390

*Kb  7.24529394385
*Kc  8.2920273339

.control

op

echo "op_TAB"
print all
echo "op_END"
quit

.endc
