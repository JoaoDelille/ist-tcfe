*Analise do t2
.options savecurrents
Vs   1    0   5.24841080700
R1   1    2   1.02166163214
R2   2    3   2.05713464724
R3   2    5   3.10288701080
R4   0    5   4.16870321182
R5   5    6   3.01167607597
R6   0   7.1  2.04520070018
Ve  7.1  7.2  0.00000000000
R7  7.2   8   1.02576029486

*C    6    8   1.00334118042

Hc  5 8  Ve   8.29202733390
Gb  6 3 (2,5) 7.24529394385m

*C  = 1.00334118042
*Kb = 7.24529394385
*Kd = 8.29202733390

*alternada, ver como escrever Vs = 5.24841080700
*ajudem a descobrir o que e pedido no Vs pffv

.control

op

echo "op_TAB"
print all
echo "op_END"
quit

.endc
